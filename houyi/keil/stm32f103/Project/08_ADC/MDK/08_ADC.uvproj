# Keil uVision project 08_ADC.uvproj, settings and files
target 08_ADC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,LTK_ADC
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --verbose
  group User
    ../: ADC_main.c
  group LTK_Utilities
    ../../../Utilities/USART/: LTK_USART.c
    ../../../Utilities/Retarget/: LTK_Retarget.c
    ../../../Utilities/SysTick/: LTK_SysTick.c
    ../../../Utilities/ADC/: LTK_ADC.c
    ../../../Utilities/GPIO/: LTK_GPIO.c
    ../../../Utilities/RCC/: LTK_RCC.c
    ../../../Utilities/NVIC_API/: LTK_NVIC_API.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_it.c misc.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
